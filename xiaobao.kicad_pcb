# Repository samchin/xiaobao

File README.md:

# Xiaobao

Xiaobao (小包) is a miniaturized evaluation board for the [Baochip-1x](https://github.com/baochip/baochip-1x), forked from the original [Dabao](https://github.com/baochip/dabao) design. This board was initially developed during the [MIT Residency at Seeed](https://github.com/Seeed-Studio/MakerCamp/tree/main/2026-01-MIT/Sam) in January 2026.

The board uses the [Seeed Studio XIAO](https://wiki.seeedstudio.com/SeeedStudio_XIAO_Series/) form factor, making it compatible with the XIAO ecosystem of carrier boards and accessories.

## Documentation
Go to [xiaobao.samch.in](https://xiaobao.samch.in) for additional details.

## About the Baochip-1x

The Baochip-1x is a mostly open-RTL, RISC-V microcontroller fabricated in TSMC 22nm:

| Feature | Specification |
|---------|---------------|
| CPU | Vexriscv RV32-IMAC @ 350 MHz |
| RAM | 2 MB integrated SRAM |
| Storage | 4 MB RRAM (non-volatile, similar to flash) |
| IO Accelerator | Quad-core PicoRV32 @ 700 MHz |
| USB | USB 2.0 High Speed with integrated PHY |

## Pinout

<details>
<summary> This table provides the mapping between the digital labels on the XIAO module and the internal baochip1x peripheral functions.

 </summary>

| Label | Pin ID | Name | AF1 | AF2 | AF3 | ANA/Power | BIO |
| :--- | :--- | :--- | :--- | :--- | :--- | :--- | :--- |
| **D0** | G3 | PA4 | UARTTX_0 | - | - | ADC0 | - |
| **D1** | C4 | PA5 | - | - | - | ADC1 | - |
| **D2** | F6 | PA6 | - | - | - | ADC2 | - |
| **D3** | D2 | PC14 | - | - | - | - | 30 |
| **D4** | C9 | PB12 | I2CSDA_0 | - | - | - | 12 |
| **D5** | B9 | PB11 | I2CSCL_0 | - | - | - | 11 |
| **D6** | E9 | PB14 | UARTTX_2 | - | - | - | 14 |
| **D7** | D9 | PB13 | UARTRX_2 | - | - | - | 13 |
| **D8** | F9 | PC0 | - | SPMCLK_2 | PWM_2[0] | - | 16 |
| **D9** | H9 | PC2 | - | SPMD1_2 | PWM_2[2] | - | 18 |
| **D10** | G9 | PC1 | - | SPMD0_2 | PWM_2[1] | - | 17 |
| **3V3** | A3/H4 | +3.3V | - | - | - | Power Rail | - |
| **GND** | F5/D4 | GND | - | - | - | Ground | - |
| **5V** | - | VBUS | - | - | - | Power Input | - |
| **D11** | F4 | PC6 | - | I2CSDA_3 | - | - | 22 |
| **D12** | E3 | PC5 | - | I2CSCL_3 | - | - | 21 |
| **D13** | H8 | PC3 | - | SPMCS0_2 | PWM_2[3] | - | 19 |
| **D14** | H3 | PC9 | - | - | - | - | 25 |
| **D15** | H6 | PC8 | - | - | - | - | 24 |
| **D16** | H7 | PC7 | - | - | - | - | 23 |
| **D19** | C8 | PB9 | - | - | - | - | 9 |
| **D18** | A9 | PB1 | - | - | PWM_1[1] | - | 1 |
| **D17** | E8 | PC4 | - | SPMCS1_2 | - | - | 20 |

</details>

## Resources

- [baochip.com](https://baochip.com/) — Official site with links to documentation, OS, and purchasing info
- [Coder's Guide to the Baochip-1x](https://baochip.github.io/baochip-1x/) — Hardware reference and peripheral docs
- [Dabao on Crowd Supply](https://www.crowdsupply.com/baochip/dabao) — Original eval board campaign

## License

This project is licensed under the [CERN Open Hardware License Version 2 - Weakly Reciprocal (CERN-OHL-W-2.0)](LICENSE).

You can use, modify, and distribute the design (including commercially), but if you distribute modified hardware or design files, you must release those modifications under the same license.

## Acknowledgments
Based on the [Dabao](https://github.com/baochip/dabao) evaluation board by [Baochip](https://github.com/baochip).

#### Xiaobao vs Dabao
Xiaobao is a smaller form factor variant of the Dabao eval board. Key differences:

- 6-layer PCB for higher routing density
- More GPIO broken out despite smaller size
- Onboard battery charging (LiPo)

## KiCad design xiaobao.kicad_pcb

Parts:
C1, C10: 12pF C0G; C_0201_0603Metric; Rating C0G 50V 0603; MPN CC0201JRNPO9BN120; LCSC C277478
C2, C11: 1.0uF, 10V, X5R; C_0201_0603Metric; MPN CL05A105KA5NQNC; LCSC C76935
C3, C6, C27: 1uF; C_0201_0603Metric; Voltage Rating 10V,X5R; MPN GRM033R61A105ME44D
C4, C7, C8, C13, C18: 0.1uF, 10V, X5R; C_0201_0603Metric; MPN CL05B104KO5NNNC; LCSC C76934
C5, C9, C15: 2.2uF, 6.3V, X5R; C_0201_0603Metric; MPN GRM033R60J225ME47D; LCSC C76933
C14, C17, C19, C21: 10uF; C_0402_1005Metric; Voltage Rating 10V,X5R; MPN CC0402MRX5R6BB106
C16, C20, C22: 100nF; C_0201_0603Metric; Voltage Rating 10V,X5R; MPN CC0201KRX5R6BB104
C26: 1nF; C_0201_0603Metric; Voltage Rating 16V,X7R; MPN CC0201KRX7R7BB102
D1: WS2812B-1010; 1010 RGB WS2812B
D2: PSBD2FD40V1H; DFN1006-2L; Rating 40V 1A 600mV@1A; MPN PSBD2FD40V1H
D3: LNZ8F5V6T5G; DFN1006-2L; Rating Zener 5.6V 200mW; MPN LNZ8F5V6T5G
D4: Yellow; LED-0402
D5, D6, D7, D8: B74121U0055M060; ESD-0201; Rating 5.5V; MPN B74121U0055M060
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
L1, L3: 0.47uH; L0603; Rating 2.6A; MPN TFM160808ALC-R47MTAA
Q1: LP0404N3T5G; PMOS_1.0X0.6X0.35MM; MPN LP0404N3T5G
Q2: LN237N3T5G; PMOS_1.0X0.6X0.35MM; Rating 30V 1.5A; MPN LN237N3T5G
R1: 1.5k; R_0201_0603Metric; MPN ANY; LCSC C25905
R2: 100 ohm; R_0201_0603Metric; MPN ANY; LCSC C106232
R3: 4.7M; R_0201_0603Metric; MPN ANY; LCSC C474132
R4: 10k, 1%; R_0201_0603Metric; MPN ANY; LCSC C106225
R5, R8, R11: 5.1k, 1%; R_0201_0603Metric; MPN ANY; LCSC C25905
R6: 12.1k; R_0201_0603Metric; Power Rating 1%; Part Type RES
R7: 5.1K; R_0201_0603Metric; Power Rating 1%; MPN RC0201FR-075K1L
R12: 150K; R0201; Power Rating 1%; MPN RC0201FR-07150KL
R13, R14, R16: 470K; R_0201_0603Metric; Power Rating 1%; MPN RC0201FR-07470KL
R15: 249K; R_0201_0603Metric; Power Rating 1%; MPN RC0201FR-07249KL
R19: 2.2K; R_0201_0603Metric; Power Rating 1%; MPN RC0201FR-072K2L
R20: 100R; R_0201_0603Metric; Power Rating 1%; MPN RC0201FR-07100RL
SW1, SW2: SKTAAAE010; SW4-SMD-2.8-2.6X1.6X0.53MM; MPN SKTAAAE010
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TEST-POINT'4545'; TP-D45MIL
TP9, TP10: Test Point; TP-80X40MIL; Part Type Test Point
U1: baochip1x; WLCSP-71_9x8_4.062x3.762mm
U2, U8: TPS22916CYFPR; WLCSP4-0.4-0.77X0.77X0.33MM; Rating 5.5V 2A; MPN TPS22916CYFPR
U3: SMD IC PMIC;DCDC Buck-ADJ-1A,Vin 1.95V to 5.5V,Vo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; BGA6-0.35-0.745X10.95X0.4MM; MPN SGM6029BYG/TR
U4: XIAO-HALF-HOLE-23P; MOUDLE23P-XIAO-HALF-HOLE
U5: SGM7222YWQ10/TR; QFN-10_1.4x1.8_Pitch0.4mm; LCSC C700326
U7: SGM40567-4.2XG/TR; WLCSP-0.4-0.92X1.16X0.4MM; MPN SGM40567-4.2XG/TR
U9: SMD IC PMIC;DCDC Buck-ADJ-1A,Vin 1.95V to 5.5V,Vo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; BGA6-0.35-0.745X10.95X0.4MM; MPN SGM6029CYG/TR
Y2: 48.000MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; LCSC C2450980

Connections:
+0.9V: C8.1, C11.1, C15.1, C16.1, C17.1, L1.2, U1.A4 (VDD.85), U1.E6 (VDDAO), U1.E7 (VDD.85), U1.F7 (VDD.85), U1.G7 (PF5), U3.A2 (VOS)
+3.3V: C2.1, C4.1, C7.1, C9.1, C18.1, C20.1, C21.1, L3.2, R1.2, R4.1, R8.1, U1.A3 (V3.3IN), U1.B7 (VDDIO), U1.C6 (PF9_PA0), U1.C7 (VDDIO), U1.D6 (PB0), U1.H4 (V3.3RR), U4.12 (VCC_3V3), U5.9 (VDD), U9.A2 (VOS)
/2.5V: C5.1, U1.C1 (VDD2.5)
/PA1/WS2812B_LED: D1.3 (DIN), U1.F2 (PF8_PA1)
/PA4: U1.G3 (PA4), U4.1 (GPIO1_D0/A0)
/PA5: U1.B5 (PB6), U1.C4 (PA5), U4.2 (GPIO2_D1/A1)
/PA6: U1.F6 (PA6), U4.3 (GPIO3_D2/A2)
/PA7/ADC3: C26.1, R13.1, R14.2, U1.D7 (PA7)
/PB1: U1.A9 (PB1), U4.22 (GPIO12_DVP_Y7/SPI_MISO1)
/PB2/LED: D4.-, U1.A8 (PB2)
/PB3/WS2812_PWR_EN: TP7.T, U1.A7 (PB3), U2.B2 (EN)
/PB4/BAT_ADC_EN: U1.A6 (PB4), U8.B2 (EN)
/PB5: TP5.T, U1.A5 (PB5)
/PB9: U1.C8 (PB9), U4.21 (GPIO11_DVP_Y8/SPI_MOSI1)
/PB11: U1.B9 (PB11), U4.6 (GPIO6_D5/A5/I2C_SCL)
/PB12: U1.C9 (PB12), U4.5 (GPIO5_D4/A4/I2C_SDA)
/PB13: U1.D9 (PB13), U4.8 (U0RXD_D7/RX)
/PB14: U1.E9 (PB14), U4.7 (U0TXD_D6/TX)
/PC0: U1.F9 (PC0), U4.9 (GPIO7_D8/A8/SCK)
/PC1: U1.G9 (PC1), U4.11 (GPIO9_D10/A10/MOSI)
/PC2: U1.H9 (PC2), U4.10 (GPIO8_D9/A9/MISO)
/PC3: U1.H8 (PC3), U4.17 (GPIO40_CAM_SDA/I2S_WS)
/PC4: U1.E8 (PC4), U4.23 (GPIO13_DVP_PCLK/SPI_SCK1)
/PC5: U1.E3 (PC5), U4.16 (GPIO39_CAM_SCL/I2S_SCK)
/PC6: U1.F4 (PC6), U4.15 (GPIO38_DVP_VSYNC/I2S_SD)
/PC7: U1.H7 (PC7), U4.20 (GPIO10_XMCLK/ADC_BAT)
/PC8: U1.H6 (PC8), U4.19 (GPIO42_PDM_CLK/TX1)
/PC9: U1.H3 (PC9), U4.18 (GPIO41_PDM_DATA/RX1)
/PC10: TP2.T, U1.G1 (PC10)
/PC11: TP1.T, U1.F1 (PC11)
/PC12: TP6.T, U1.E1 (PC12)
/PC13/BOOT: D7.2, R8.2, SW2.3 (B0), SW2.4 (B1), U1.D1 (PC13), U5.10 (SEL)
/PC14: U1.D2 (PC14), U4.4 (GPIO4_D3/A3)
/RST_N: C13.1, R2.2, R4.2, U1.H5 (AORSTn)
/USBCONN_N: D6.2, J1.A7 (D-), J1.B7 (D-), TP3.T, U5.2 (C0-)
/USBCONN_P: D5.2, J1.A6 (D+), J1.B6 (D+), TP4.T, U5.1 (C0+)
/USBC_CC1: J1.A5 (CC1), R5.2
/USBC_CC2: J1.B5 (CC2), R11.2
/USBC_N: U1.B1 (USB_D-), U5.6 (L1-)
/USBC_P: U1.A2 (USB_D+), U5.7 (L1+)
/XI_48M: C1.1, R3.2, U1.H1 (X48MI), Y2.1 (X1)
/XO_48M: C10.2, R3.1, U1.H2 (X48MO), Y2.3 (X2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C26.2, C27.2, D1.2 (VSS), D5.1, D6.1, D7.1, D8.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), Q2.2 (S), R5.1, R6.1, R11.1, R12.1, R14.1, R15.1, R16.1, R19.1, SW1.1 (A0), SW1.2 (A1), SW2.1 (A0), SW2.2 (A1), TP8.T, TP10.1 (T), U1.B2 (GND), U1.C3 (GND), U1.C5 (GND), U1.D4 (GND), U1.D5 (GND_TP), U1.F5 (GND), U1.G5 (PF4), U2.B1 (GND), U3.A1 (GND), U4.13 (GND), U5.3 (GND), U5.4 (L0-), U5.5 (L0+), U5.8 (EN), U7.B1 (F), U7.C2 (GND), U8.B1 (GND), U9.A1 (GND), Y2.2 (CASE2), Y2.4 (CASE4)
unnamed: D1.4 (VDD), U2.A1 (VOUT)
unnamed: D4.+, R1.1
unnamed: Q1.1 (G), R20.2
unnamed: D3.1, Q2.1 (G), R19.2
unnamed: R2.1, SW1.3 (B0), SW1.4 (B1)
unnamed: R6.2, U3.C1 (MODE)
unnamed: L1.1, U3.B2 (SW)
unnamed: R12.2, U7.C1 (IREF)
unnamed: R7.1, U7.B2 (NCHG)
unnamed: C27.1, R13.2, U8.A1 (VOUT)
unnamed: R15.2, U9.C1 (MODE)
unnamed: L3.1, U9.B2 (SW)
VBAT: C6.1, Q1.3 (D), TP9.1 (T), U7.A1 (BAT), U8.A2 (VIN)
VBUS: C3.1, C22.1, D2.1, D3.2, D8.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q2.3 (D), R7.2, R16.2, R20.1, U4.14 (VBUS), U7.A2 (VIN)
VSYS: C14.1, C19.1, D2.2, Q1.2 (S), U2.A2 (VIN), U3.B1 (VIN), U3.C2 (EN), U9.B1 (VIN), U9.C2 (EN)

Notes on the sheet:
DC-DC Buck Regulators
External regulator needed for full frequency operation Thermal dissipation is too high using LDO alone Set to 0.85 V using a 12.1k resistor
This pinout footprint is based on the XIAO ESP32-S3 Plus
0.85V
Baochip
Battery Management
H8 would be a good candidate if more pins are needed
xiao bao (小保)
Xiao Pinouts
ICharge=24000/150K=160mA
Indicator LEDs
press to toggle bootloader mode (also disconnects USB)
3.3V
USB C
User Input Buttons

Board: 6 copper layers, 17.8 x 21.1 mm, 73 parts (10 on the bottom side), 58 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10",0201,2,12pF C0G,C277478
"C11, C2",0201,2,"1.0uF, 10V, X5R",C76935
"C13, C18, C4, C7, C8",0201,5,"0.1uF, 10V, X5R",C76934
"C14, C17, C19, C21",0402,4,10uF,C315248
"C15, C5, C9",0201,3,"2.2uF, 6.3V, X5R",C76933
"C16, C20, C22",0201,3,100nF,C76934
C26,0201,1,1nF,C85934
"C27, C3, C6",0201,3,1uF,C76935
D1,1010 RGB WS2812B,1,WS2812B-1010,C5349953
D2,DFN1006-2L,1,PSBD2FD40V1H,C492733
D3,DFN1006-2L,1,LNZ8F5V6T5G,C383251
D4,LED-0402,1,Yellow,C74340
"D5, D6, D7, D8",ESD-0201,4,B74121U0055M060,C20344325
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0_16P,C165948
"L1, L3",L0603,2,0.47uH,C882988
Q1,PMOS_1.0X0.6X0.35MM,1,LP0404N3T5G,C172433
Q2,PMOS_1.0X0.6X0.35MM,1,LN237N3T5G,C383245
R1,0201,1,1.5k,C25905
"R11, R5, R8",0201,3,"5.1k, 1%",C25905
R12,R0201,1,150K,C274346
"R13, R14, R16",0201,3,470K,C274343
R15,0201,1,249K,C2108970
R19,0201,1,2.2K,C142018
R2,0201,1,100 ohm,C106232
R20,0201,1,100R,RC0201FR-07100RL
R3,0201,1,4.7M,C474132
R4,0201,1,"10k, 1%",C106225
R6,0201,1,12.1k,C423764
R7,0201,1,5.1K,C163490
"SW1, SW2",SW4-SMD-2.8-2.6X1.6X0.53MM,2,SKTAAAE010,C358616
U1,WLCSP-71_9x8_4.062x3.762mm,1,baochip1x,
"U2, U8",WLCSP4-0.4-0.77X0.77X0.33MM,2,TPS22916CYFPR,C2680319
U3,BGA6-0.35-0.745X10.95X0.4MM,1,"SMD IC PMIC;DCDC Buck-ADJ-1A,Vin 1.95V to 5.5V,Vout 0.8V to 1.55V;WLCSP-6B",C5153504
U5,QFN-10_1.4x1.8_Pitch0.4mm,1,SGM7222YWQ10/TR,C700326
U7,WLCSP-0.4-0.92X1.16X0.4MM,1,SGM40567-4.2XG/TR,C5141336
U9,BGA6-0.35-0.745X10.95X0.4MM,1,"SMD IC PMIC;DCDC Buck-ADJ-1A,Vin 1.95V to 5.5V,Vout 1.8V to 3.3V;WLCSP-6B",C5153500
Y2,Crystal_SMD_2016-4Pin_2.0x1.6mm,1,48.000MHz,C2450980

## Commit log

2026-01-20 initial placement
2026-01-21 some bunnie edits, battery charging added
2026-01-22 tentative bao layout
2026-01-23 clean DRC v1
2026-01-23 now with more pins
2026-01-23 clean-drc, now more pads
2026-01-23 now with silk and logos and an led
2026-01-23 now with 2 more pins
2026-01-23 with pc0-pc9 and pb11-pb14
2026-01-23 fixed the fact that pa0 was a lie
2026-01-29 stray wire removal
2026-01-29 nearly final
2026-01-29 nit pick fix
2026-01-29 production pt 2
2026-01-29 flag day wheeee~
2026-01-29 production files for real
2026-02-01 now with better documentation and a slightly clearer schematic
2026-02-02 docs: init
2026-02-02 move documentation -> docs/assets
2026-02-02 cname -> docs
2026-02-02 interactive bom fun
2026-02-02 docs: unnest and link bom page
2026-02-02 docs: init pinout from pico.pinout.xyz
2026-02-02 cute pinouts
2026-02-02 xiaobao pinouts
2026-02-02 updating csv
2026-02-02 cleaning up some docs, making it more maintainable
2026-02-02 backporting some dabao changes
2026-02-03 more visual improvements and streamlining
